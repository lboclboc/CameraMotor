# Repository lboclboc/CameraMotor

File README.md:

# CameraMotor
Motorized equatorial camera mount.

This is the code for the EQ-Camera thingiverse mount at https://www.thingiverse.com/thing:3594100.
The current development is focusing on a ESP8266 wifi enabled controller that also will be able to do timelapsing for other purposes 
than astrophotographing.

## KiCad design KiCad/CameraMotor.kicad_pcb

Parts:
C1, C3: 100u; CP_Elec_5x3.9
C2: 100n; C_1206_3216Metric
F1: Polyfuse; Fuse_SMS-5.2x4.2mm
J1: USB_OTG; USB_Micro-USB3135-30-A
J2: XH JST 800921; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J4: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
PROG1: SW_DIP_x01; SW_Push_1P1T_NO_6x6mm_H9.5mm
R1, R4, R5, R7: 4K7; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R6: 39; R_Axial_DIN0617_L17.0mm_D6.0mm_P7.62mm_Vertical
RES1: SW_DIP_x01; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: ESP-12E
U2: ULN2003; SOIC-16_3.9x9.9mm_Pitch1.27mm
U3: LM1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C2.1, C3.1, R1.2, R4.2, R5.2, U1.8 (VCC), U3.2 (VO)
+5VD: C1.1, F1.2, J2.5, R6.1, U2.9 (COM), U3.3 (VI)
/Blue: J2.1, U2.16 (O1)
/Focus: J4.2, U2.10 (O7)
/Orange: J2.4, U2.13 (O4)
/Pink: J2.2, U2.15 (O2)
/Shutter: J4.1, U2.11 (O6)
/Yellow: J2.3, U2.14 (O3)
GNDD: C1.2, C2.2, C3.2, J1.5 (GND), J1.6 (Shield), J3.1, J4.3, PROG1.2, R7.1, RES1.2, U1.15 (GND), U2.8 (GND), U3.1 (GND)
unnamed: F1.1, J1.1 (VBUS)
unnamed: J3.2, U1.22 (GPIO1/TXD)
unnamed: J3.3, U1.21 (GPIO3/RXD)
unnamed: PROG1.1, R1.1, U1.18 (GPIO0)
unnamed: R4.1, U1.3 (EN)
unnamed: R5.1, RES1.1, U1.1 (~RST)
unnamed: R6.2, U2.12 (O5)
unnamed: R7.2, U1.16 (GPIO15), U2.4 (I4)
unnamed: U1.4 (GPIO16), U2.5 (I5)
unnamed: U1.5 (GPIO14), U2.3 (I3)
unnamed: U1.6 (GPIO12), U2.1 (I1)
unnamed: U1.7 (GPIO13), U2.2 (I2)
unnamed: U1.19 (GPIO4), U2.6 (I6)
unnamed: U1.20 (GPIO5), U2.7 (I7)

Board: 2 copper layers, 51.4 x 40.0 mm, 18 parts (0 on the bottom side), 23 nets.

## KiCad design KiCad/ExternalPCBService/CameraMotor-external.kicad_pcb

Parts:
C1: 100u; CP_Elec_8x5.4
C2: 100n; C_1206
C3, C4: 20p; C_1206
D1, D2, D3, D4, D5: 1N4148; D_MiniMELF
F1: Polyfuse; Fuse_SMS-5.2x4.2mm
J1: USB_OTG; USB_Micro-USB3135-30-A
J2: Conn_01x05; JST_XH_B05B-XH-A_05x2.50mm_Straight
J7: Conn_01x02; Pin_Header_Straight_1x02_Pitch2.54mm
J9: Conn_02x03_Odd_Even; Pin_Header_Straight_2x03_Pitch2.54mm
Q1, Q2, Q3, Q4, Q5, Q6: Q_NMOS_GDS; SOT-23
R1, R3, R4: 680; R_1206_HandSoldering
R2: 39; R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal
U1: ATTINY441-SSU; SOIC-14_N
Y1: Crystal; Resonator-SMD_2pin_10.0x5.0x4.5mm

Connections:
+5VD: C1.1, C2.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), F1.2, J2.5, J9.2, R2.2, U1.1 (VCC)
/MISO: R3.2, U1.8 ((PCINT5/MISO/TXD1/T2/TOCC4/ACO0/ADC5)PA5)
/MOSI: R4.2, U1.7 ((PCINT6/MOSI/SDA/XCK1/TOCC5/ACO1/ADC6)P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)
/PA0: Q4.1 (G), U1.13 ((PCINT0/MISO/AREF/ADC0)PA0)
/PA1: Q3.1 (G), U1.12 ((PCINT1/MOSI/TXD0/TOCC0/AIN00/ADC1)PA1)
/PA2: Q2.1 (G), U1.11 ((PCINT2/~SS~/RXD0/TOCC1/AIN01/ADC2)PA2)
/PA3: Q1.1 (G), U1.10 ((PCINT3/SCK/XCK0/T0/TOCC2/AIN10/ADC3)PA3)
/PA7: Q5.1 (G), U1.6 ((PCINT7/~SS~/TXD0/ICP1/TOCC6/ADC7)PA7)
/RESET: J9.5, U1.4 ((PCINT11/dW/~RESET~/ADC9)PB3)
/SCK: R1.2, U1.9 ((PCINT4/SCK/SCL/RXD1/T1/TOCC3/AIN11/ADC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)
/SHUTTERN: D5.2 (A), J7.1, Q6.3 (D)
/XTAL1: C3.1, U1.2 ((PCINT8/CLKI/XTAL1/ADC11)PB0), Y1.1
/XTAL2: C4.1, U1.5 ((PCINT10/RXD0/ICP2/CLKO/TOCC7/ADC8)PB2), Y1.2
GNDD: C1.2, C2.2, C3.2, C4.2, J1.5 (GND), J1.6 (Shield), J7.2, J9.6, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), U1.14 (GND)
unnamed: D1.2 (A), J2.1, Q1.3 (D)
unnamed: D2.2 (A), J2.2, Q2.3 (D)
unnamed: D3.2 (A), J2.3, Q3.3 (D)
unnamed: D4.2 (A), J2.4, Q4.3 (D)
unnamed: F1.1, J1.1 (VBUS)
unnamed: J9.1, R3.1
unnamed: J9.3, R1.1
unnamed: J9.4, R4.1
unnamed: Q5.3 (D), R2.1
unnamed: Q6.1 (G), U1.3 ((PCINT9/INT0/XTAL2/ADC10)PB1)

Board: 2 copper layers, 51.4 x 40.0 mm, 26 parts (0 on the bottom side), 24 nets.

## Code that names these connections

File Code/components/include/Stepper.h:

/*
 * Stepper.h
 *
 *  Created on: May 4, 2019
 *      Author: lasse
 */

#ifndef STEPPER_H_
#define STEPPER_H_
#include <driver/gpio.h>

typedef void (*step_callback_t)(void);

class Stepper
{
public:
	Stepper(gpio_num_t b=GPIO_NUM_12,
			gpio_num_t p=GPIO_NUM_13,
			gpio_num_t y=GPIO_NUM_14,
			gpio_num_t o=GPIO_NUM_15,
			float period=1.0,
			step_callback_t step_callback=0);
	virtual ~Stepper();
	void step();
	float set_period(float seconds);
	void set_step_callback(step_callback_t cb) { step_callback = cb; }
	void init();
	static const int fwd = -1;
	static const int rev = 1;

protected:
	void run();

private:
	static void timer_callback(void *);
	gpio_num_t orange_pin;	// Pin number for leeds
	gpio_num_t yellow_pin;
	gpio_num_t pink_pin;
	gpio_num_t blue_pin;
	long current_pos;		// Current stepper position
	short current_phase;
	unsigned long ticks;		// Number of ticks between stepping.
	short direction;
	const static unsigned char phases[8];
	step_callback_t step_callback;
	unsigned short prescaler;
};

#endif /* STEPPER_H_ */

## Commit log

2019-03-14 Initial checkin to git
2019-03-14 Re-calibrated after full turn times.
2019-03-16 Safer powerbank settings.
2019-03-17 Removed cyclic error but missing things.
    Missing PCB cover and mirrored camera mount.
2019-03-17 Rework
    Remade the camera tilt.
    Increased the thickness
    Allow for screw to slide in the camera rail.
2019-04-28 Created
2019-04-28 Imported from private SVN
2019-04-28 Ignores + photo
2019-04-28 Half way changing to ATtiny-441
2019-04-28 cleanup
2019-04-30 Fully routed with ATtiny-414
2019-04-30 Restructure
2019-04-30 Minor
2019-05-01 Backup
2019-05-03 Started web based controller with ESP8266
2019-05-05 Wifi connects
2019-05-12 Fully routed
2019-05-12 Setting period works but not aborting current wait.
2019-05-26 Added rescue-lib
2019-06-01 Finalized PCB
2019-06-09 Reworked after missing soldermask.
2019-06-09 Calculated correct sidereal timing.
2019-06-09 Added sidereal as a template variable.
2019-06-09 Added README.md
2019-06-25 Added BOM
2019-06-25 Backup before going AP
2019-06-25 Working as a AP now.
    IP address will be 192.168.4.1
    The ssid will be EQCAMxxxxxx where x is the last 3 hex values
    from the mac address.
2019-06-25 Removed resistors.
    The resistors for Tx and Rx did not work, these inputs has pullups
    that was distorting the levels.
2019-06-26 Modified PCB-cover
2019-06-26 SMaller USB window
2019-06-26 Corrected direction for northen hemisphere.
2019-06-27 Smashed a couple of bugs.
2019-06-27 Using HW-timers.
2019-06-27 HTML nicer and show 360 turn time.
2019-07-26 Fixed better CameraTilt
2019-07-26 Generated STL
2020-11-29 Added direction
2020-11-29 Halfway through upgrading to latest esp-idf with cmake
